<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR\Stack\CC2650\CC2650Stack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IAR\Application\FreeWrite\FreeWrite.ewp</path>
  </project>
  <batchBuild/>
</workspace>


