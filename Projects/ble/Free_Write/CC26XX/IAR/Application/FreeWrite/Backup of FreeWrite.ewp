# IAR project Backup of FreeWrite.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: POWER_SAVING; GATT_TI_UUID_128_BIT; FEATURE_REGISTER_SERVICE; USE_ICALL; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_I2C_INCLUDED; TI_DRIVERS_SPI_INCLUDED; TI_DRIVERS_UART_INCLUDED; HEAPMGR_SIZE=2872; ICALL_MAX_NUM_TASKS=8; ICALL_MAX_NUM_ENTITIES=11; CC26XXWARE; CC26XX; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application/Board_patch/Board; ../../../Source/Application/Board_patch/interfaces; ../../../Source/Application/Board_patch/devices; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/ICall/Include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/Roles/CC26xx; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/Roles; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/Keys; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/DevInfo; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/SensorProfile/cc26xx; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/Profiles/OAD/cc26xxST; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Projects/ble/common/cc26xx; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/applib/heap; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/ble/hci; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/ble/controller/CC26xx/include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/ble/host; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/hal/target/CC2650TIRTOS; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/hal/target/_common/cc26xx; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/hal/include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/osal/include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/services/sdata; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/services/saddr; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/icall/include; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/icall/ports/tirtos; C:/ti/simplelink/ble_cc26xx_2_01_01_44627/Components/ble/include; $TI_RTOS_DRIVERS_BASE$; $CC26XXWARE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeWrite.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: FreeWrite.out
  ILINK.IlinkIcfFile: cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application
    ../../../Source/Application/: AHRS.c AHRS.h Controller.c Controller.h Controller_ConnCtrl.c Controller_ConnCtrl.h Controller_Keys.c Controller_Keys.h Fig.c Fig.h
    ../../../../../common/cc26xx/: util.c util.h
  group Board/Devices
    ../../../Source/Application/Board_patch/Devices/: sensor_mpu9250_mux.c sensor_mpu9250_mux.h
  group Board/Interfaces
    ../../../Source/Application/Board_patch/Board/: Board.c Board.h sensor.c sensor.h
    ../../../Source/Application/Board_patch/Interfaces/: bsp_adc.c bsp_adc.h bsp_i2c.c bsp_i2c.h bsp_uart.c bsp_uart.h
  group Board/SensorController
    ../../../Source/Application/SensorController/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.c scif_osal_tirtos.h
  group Drivers/ADC
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: ADC.c ADC.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/adc/: ADCCC26XX.c ADCCC26XX.h
  group Drivers/I2C
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: I2C.c I2C.h
    ../../../Source/Application/Board_patch/Interfaces/: I2CCC26XX.c
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/i2c/: I2CCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../Source/Application/ICallBLE/: bleUserConfig.c bleUserConfig.h
    ../../../../../ICall/Application/: ICallBleAPI.c
    ../../../../../ICall/Include/: ICallBleAPIMSG.h
  group Include
    ../../../../../Include/: gapgattserver.h gatt_profile_uuid.h gattservapp.h gatttest.h hci_ext.h
  group PROFILES
    ../../../Source/Application/: ahrsservice.c ahrsservice.h figservice.c figservice.h recordservice.c recordservice.h st_util.c st_util.h
    ../../../../../Profiles/DevInfo/CC26xx/: devinfoservice.c
    ../../../../../Profiles/DevInfo/: devinfoservice.h
    ../../../Source/Application/Profile/: gapgattserver.h peripheral.c peripheral.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
  group Startup
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    ./: cc26xx_ble_app.icf
